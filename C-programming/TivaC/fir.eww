<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\First,c.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Second.ewp</path>
    </project>
    <batchBuild />
</workspace>
